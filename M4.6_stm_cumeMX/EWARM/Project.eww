<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\M4.6_stm_cumeMX.ewp</path>
  </project>
  <batchBuild />
</workspace>
